# Keil uVision project gd32207i-eval.uvprojx, settings and files
target gd32207i-eval (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F207IK GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gd32207i-eval
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_ENET_INTERRUPT CONFIG_MEDTLS_USE_AFR_MEMORY NDEBUG
  c include: ..\..\..\..\vendors\gd32\boards\gd32207i-eval\aws_tests\config_files;..\..\..\..\libraries\3rdparty\unity\src;..\..\..\..\libraries\3rdparty\unity\extras\fixture\src;..\..\..\..\freertos_kernel\include;..\..\..\..\freertos_kernel\portable\RVDS\ARM_CM3;..\..\..\..\libraries\freertos_plus\standard\freertos_plus_tcp\include;..\..\..\..\libraries\freertos_plus\standard\freertos_plus_tcp\portable\Compiler\Keil;..\..\..\..\tests\include;..\..\..\..\libraries\freertos_plus\standard\utils\include;..\..\..\..\libraries\freertos_plus\standard\crypto\include;..\..\..\..\libraries\3rdparty\mbedtls\include;..\..\..\..\libraries\3rdparty\mbedtls_config;..\..\..\..\libraries\freertos_plus\standard\freertos_plus_tcp\portable\NetworkInterface\gd32207i-eval;..\..\..\..\libraries\abstractions\secure_sockets\include;..\..\..\..\libraries\c_sdk\standard\common\include\private;..\..\..\..\libraries\freertos_plus\standard\tls\include;..\..\..\..\libraries\abstractions\pkcs11\corePKCS11\source\include;..\..\..\..\libraries\3rdparty\pkcs11;..\..\..\..\libraries\3rdparty\mbedtls_utils;..\..\..\..\libraries\abstractions\platform\freertos\include;..\..\..\..\libraries\c_sdk\standard\common\include;..\..\..\..\libraries\abstractions\transport\secure_sockets;..\..\..\..\libraries\coreMQTT\source\include;..\..\..\..\libraries\coreMQTT\source\interface;..\..\..\..\libraries\abstractions\backoff_algorithm\source\include;..\..\..\..\libraries\coreMQTT-Agent\source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group FreeRTOS-Kernel
    ../../../../freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../freertos_kernel/portable/MemMang/: heap_4.c
    ../../../../freertos_kernel/portable/RVDS/ARM_CM3/: port.c
  group application_code
    ../../../../vendors/gd32/boards/gd32207i-eval/aws_tests/application_code/: main.c
    ./: ButtonTask.c
  group 3rd_unity
    ../../../../libraries/3rdparty/unity/src/: unity.c
    ../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
  group library_FreeRTOS+_utils
    ../../../../libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group library_FreeRTOS+_crypto
    ../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group library_3rdparty_mbedtls
    ../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group FreeRTOS+TCP
    ../../../../libraries/freertos_plus/standard/freertos_plus_tcp/portable/BufferManagement/: BufferAllocation_2.c
    ../../../../libraries/freertos_plus/standard/freertos_plus_tcp/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
    ../../../../libraries/freertos_plus/standard/freertos_plus_tcp/portable/NetworkInterface/gd32207i-eval/: gd32f20x_enet_eval.c NetworkInterface.c
  group secure_socket
    ../../../../libraries/abstractions/secure_sockets/freertos_plus_tcp/: iot_secure_sockets.c
  group library_tls
    ../../../../libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group library_pkcs11
    ../../../../libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
    ../../../../libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group pcks11_pal
    ../../../../vendors/gd32/boards/gd32207i-eval/ports/pkcs11/: core_pkcs11_pal.c
  group secure_socket_test_tcp
    ../../../../libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
  group test_common
    ../../../../tests/common/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_freertos.c iot_tests_network.c
  group transport_secure_socket
    ../../../../libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c
  group coreMQTT
    ../../../../libraries/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group coreMQTT_test
    ../../../../tests/integration_test/: core_mqtt_system_test.c
  group backoff
    ../../../../libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
  group coreMQTT-Agent
    ../../../../libraries/coreMQTT-Agent/source/: core_mqtt_agent.c core_mqtt_agent_command_functions.c
software components: CMSIS:CORE 5.5.0, Device:EVAL:GD32F207i 2.2.0, Device:GD32F20x_StdPeripherals:CAU 2.2.0, Device:GD32F20x_StdPeripherals:CRC 2.2.0, Device:GD32F20x_StdPeripherals:DMA 2.2.0, Device:GD32F20x_StdPeripherals:ENET 2.2.0, Device:GD32F20x_StdPeripherals:EXTI 2.2.0, Device:GD32F20x_StdPeripherals:FMC 2.2.0, Device:GD32F20x_StdPeripherals:GPIO 2.2.0, Device:GD32F20x_StdPeripherals:HAU 2.2.0, Device:GD32F20x_StdPeripherals:MISC 2.2.0, Device:GD32F20x_StdPeripherals:PMU 2.2.0, Device:GD32F20x_StdPeripherals:RCU 2.2.0, Device:GD32F20x_StdPeripherals:RTC 2.2.0, Device:GD32F20x_StdPeripherals:TIMER 2.2.0, Device:GD32F20x_StdPeripherals:TRNG 2.2.0, Device:GD32F20x_StdPeripherals:USART 2.2.0, Device:GD32F20x_libopt 2.2.0, Device:Startup 2.2.0
